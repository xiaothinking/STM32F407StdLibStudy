# Keil uVision project usb.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sdio +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F40_41xxx, USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Souce;..\..\USB\USB_APP;..\..\USB\STM32_USB_Device_Library\Class\msc\inc;..\..\USB\STM32_USB_Device_Library\Core\inc;..\..\USB\STM32_USB_OTG_Driver\inc;..\..\USB\STM32_USB_Device_Library\Class\hid\inc;..\..\USB\STM32_USB_Device_Library\Class\dfu\inc;..\..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\..\USB\STM32_USB_Device_Library\Class\audio\inc;..\..\USB\STM32_USB_HOST_Library\Class\HID\inc;..\..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\..\USB\STM32_USB_HOST_Library\Core\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Souce/: system_stm32f4xx.c
  group USER
    ../Souce/: main.c delay.c uart.c key.c stm32f4xx_it.c malloc.c sdio.c spi.c w25qxx.c led.c lcd.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_fsmc.c
  group USB_OTG
    ../../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../../USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
