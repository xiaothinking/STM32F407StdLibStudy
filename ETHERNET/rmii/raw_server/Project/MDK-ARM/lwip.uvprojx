# Keil uVision project lwip.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lwip +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Souce;..\..\USMART;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\LWIP\lwip-1.4.1\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\lwip-1.4.1\src\include\ipv4;..\..\LWIP\lwip-1.4.1\lwip-1.4.1\src\include\netif;..\..\LWIP;..\..\LWIP\arch;..\..\LWIP\lwip_app\lwip_comm;..\..\LWIP\lwip_app\tcp_server_demo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Souce/: system_stm32f4xx.c
  group USER
    ../Souce/: main.c delay.c uart.c lcd.c stm32f4xx_it.c timer.c key.c sram.c malloc.c lan8720.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c stm32f4xx_tim.c
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group USMART
    ../../USMART/: usmart.c usmart_config.c usmart_str.c
  group LWIP-NETIF
    ../../LWIP/lwip-1.4.1/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../../LWIP/lwip-1.4.1/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../LWIP/lwip-1.4.1/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-API
    ../../LWIP/lwip-1.4.1/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-ARCH
    ../../LWIP/arch/: sys_arch.c
  group LWIP-APP
    ../../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../../LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
